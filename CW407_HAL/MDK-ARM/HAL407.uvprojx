# Keil uVision project HAL407.uvprojx, settings and files
target HAL407 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: HAL407
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;        ../Middlewares/Third_Party/LwIP/src/include;        ../Middlewares/Third_Party/LwIP/system;        ../Drivers/STM32F4xx_HAL_Driver/Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;        ../Middlewares/Third_Party/FatFs/src/drivers;        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;        ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;        ../Middlewares/Third_Party/FatFs/src;        ../Middlewares/Third_Party/FreeRTOS/Source/include;        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;        ../Middlewares/Third_Party/LwIP/src/include/lwip;        ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;        ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;        ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;        ../Middlewares/Third_Party/LwIP/src/include/netif;        ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;        ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;        ../Middlewares/Third_Party/LwIP/src/include/posix;        ../Middlewares/Third_Party/LwIP/src/include/posix/sys;        ../Middlewares/Third_Party/LwIP/system/arch;        ../Drivers/CMSIS/Include;        ..\App;        ..\Drivers\BSP;    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c queue.c list.c croutine.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: ethernetif.c stm32f4xx_it.c freertos.c lwip.c stm32f4xx_hal_msp.c bsp_driver_sd.c main.c stm32f4xx_hal_timebase_TIM.c fatfs.c usbd_desc.c usb_device.c usbd_storage_if.c usbd_conf.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: netdb.c sockets.c api_msg.c netbuf.c netifapi.c api_lib.c err.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ethip6.c icmp6.c ip6_addr.c inet6.c dhcp6.c ip6.c ip6_frag.c nd6.c mld6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppos.c upap.c mppe.c pppol2tp.c ipcp.c multilink.c ecp.c auth.c vj.c ppp.c fsm.c ccp.c utils.c chap_ms.c lcp.c ipv6cp.c eui64.c pppapi.c chap-md5.c demand.c pppcrypt.c magic.c pppoe.c chap-new.c eap.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp.c pbuf.c timeouts.c tcp_out.c udp.c tcp_in.c def.c memp.c init.c mem.c stats.c raw.c inet_chksum.c ip.c netif.c dns.c sys.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c etharp.c autoip.c ip4.c dhcp.c icmp.c ip4_frag.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md5.c sha1.c des.c arc4.c md4.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_usb.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sram.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_eth.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/Bsp
    ../Drivers/BSP/: bsp.c bsp_cpu_flash.c bsp_eeprom_24xx.c bsp_modbus.c bsp_port.c bsp_uart_fifo.c bsp_user_lib.c param.c
  group App
    ../App/: app.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_scsi.c usbd_msc_data.c usbd_msc_bot.c usbd_msc.c
software components: CMSIS:CORE 4.1.0
